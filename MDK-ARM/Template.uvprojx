# Keil uVision project Template.uvprojx, settings and files
target Integrator (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303RE STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Integrator +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F30X,
  c include: ..\..\timer;..\CMSIS;..\inc_perip
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group inc_perip
    ../inc_perip/: stm32f30x_rcc.c stm32f30x_gpio.c stm32f30x_adc.c stm32f30x_misc.c stm32f30x_tim.c stm32f30x_dma.c stm32f30x_syscfg.c stm32f30x_exti.c
  group User
    ../: main.c stm32f30x_it.cpp
  group System
    ../: system_stm32f30x.c startup_stm32f30x.s
